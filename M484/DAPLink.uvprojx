# Keil uVision project DAPLink.uvprojx, settings and files
target M484 (6160000::V6.16::ARMCLANG)
  device: M484SIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.14
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: DAPLink +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.dis" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DAP_FW_V1
  c include: .\src\CSL\CMSIS\CoreSupport;.\src\CSL\CMSIS\DeviceSupport;.\src\CSL\NUCM480_StdPeriph_Driver;.\src;..\core\DAP;..\core\SWD_host
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group APP
    ./src/: main.c descriptors.c hid_transfer.c vcom_serial.c
  group DAP
    ../core/DAP/: DAP.c SW_DP.c JTAG_DP.c
  group SWD_host
    ../core/SWD_host/: SWD_host.c
  group CSL/StdPD
    ./src/CSL/NUCM480_StdPeriph_Driver/: clk.c gpio.c uart.c hsusbd.c
  group CSL/CMSIS
    ./src/CSL/CMSIS/DeviceSupport/: system_M480.c
    ./src/CSL/CMSIS/DeviceSupport/startup/arm/: startup_M480.s
