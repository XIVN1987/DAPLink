# Keil uVision project DAPLink.uvprojx, settings and files
target AT32F425 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F425F8P7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: DAPLink +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.dis" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F425F8P7,USE_STDPERIPH_DRIVER, DAP_FW_V1
  c include: .\src;.\src\CSL\CMSIS\core_support;.\src\CSL\CMSIS\device_support;.\src\CSL\AT32F425_StdPeriph_Driver;.\src\CSL\AT32F425_USB_Lib;..\core\DAP\Include;..\core\SWD_host
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./src/: main.c descriptor.c hid_transfer.c vcom_serial.c
  group DAP
    ../core/DAP/Source/: DAP.c SW_DP.c JTAG_DP.c
  group SWD_host
    ../core/SWD_host/: SWD_host.c
  group CSL/USBD
    ./src/CSL/AT32F425_USB_Lib/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group CSL/StdPD
    ./src/CSL/AT32F425_StdPeriph_Driver/: at32f425_acc.c at32f425_crm.c at32f425_gpio.c at32f425_tmr.c at32f425_usart.c at32f425_usb.c at32f425_dma.c
  group CSL/CMSIS
    ./src/CSL/CMSIS/device_support/: system_at32f425.c
    ./src/CSL/CMSIS/device_support/startup/mdk/: startup_at32f425.s
